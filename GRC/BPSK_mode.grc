options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: epirb
    output_language: python
    title: EPIRB Tx/Demod demo
  states: {}

blocks:
- name: bits_per_second
  id: variable
  parameters:
    value: '400.0'
  states: {}
- name: f_offset
  id: variable
  parameters:
    value: 25e3
  states: {}
- name: frame_sync_test_0
  id: variable
  parameters:
    value: '[0,1,1,0,1,0,0,0,0]'
  states: {state: disabled}
- name: gain_mu
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0
    label: Gain Mu
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '0.9'
    value: '0.2'
  states: {state: disabled}
- name: gain_omega
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: Gain Omega
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '0.5'
    value: '0.052'
  states: {state: disabled}
- name: phase_offset_radians
  id: variable
  parameters:
    value: '1.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bits_per_second*symbols_per_bit*samples_per_symbol*5.0*5.0*5.0
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '10'
  states: {}
- name: symbols_per_bit
  id: variable
  parameters:
    value: '2.0'
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: phase_offset_radians
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1.0'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 1.0/2.0
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1.0'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/syed/Downloads/example_file
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1.0'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samples_per_symbol)
    type: byte
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: int(symbols_per_bit*samples_per_symbol)
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: f_offset/(samp_rate/2.0)*cmath.pi
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sample_and_hold_xx_0_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.5'
    init: '1'
    low: '0.5'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '-2.5'
    init: '0'
    low: '-2.5'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: int(symbols_per_bit)
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {state: disabled}
- name: channels_dynamic_channel_model_0
  id: channels_dynamic_channel_model
  parameters:
    K: '4.0'
    LOS: 'True'
    N: '8'
    cfo_maxdev: '100'
    cfo_stdev: '0.001'
    delays: 0.0,0.1,1.3
    fD: '2.0'
    mags: 1,0.99,0.97
    noise_amp: '1.0'
    ntaps: '8'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {state: disabled}
- name: digital_correlate_access_code_tag_bb_0
  id: digital_correlate_access_code_tag_bb
  parameters:
    access_code: '1010101010101010101010101010100'
    tagname: rx_sync
    threshold: '0'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: cmath.pi/4000.0
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1,2,0,3]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '5'
    samp_delay: int((len(firdes.low_pass_2(5.0, bits_per_second*symbols_per_bit*samples_per_symbol*5, 3700, 300, 40, firdes.WIN_BLACKMAN_HARRIS))-1)/2)
    taps: firdes.low_pass_2(5.0, bits_per_second*symbols_per_bit*samples_per_symbol*5, 3700, 300, 40, firdes.WIN_BLACKMAN_HARRIS)
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_1_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '5'
    samp_delay: int((len(firdes.low_pass_2(5.0, bits_per_second*symbols_per_bit*samples_per_symbol*5*5, 25000, 5000, 40, firdes.WIN_BLACKMAN_HARRIS))-1)/2)
    taps: firdes.low_pass_2(5.0, bits_per_second*symbols_per_bit*samples_per_symbol*5*5, 25000, 5000, 40, firdes.WIN_BLACKMAN_HARRIS)
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_1_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '5'
    samp_delay: int((len(firdes.low_pass_2(5.0, bits_per_second*symbols_per_bit*samples_per_symbol*5*5*5, 100000, 25000, 20, firdes.WIN_BLACKMAN_HARRIS))-1)/2)
    taps: firdes.low_pass_2(5.0, bits_per_second*symbols_per_bit*samples_per_symbol*5*5*5, 100000, 25000, 20, firdes.WIN_BLACKMAN_HARRIS)
    type: ccf
  states: {}
- name: note_0
  id: note
  parameters:
    note: Modulation enable
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Tx enable
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: Manchester Encoding
  states: {}
- name: note_0_3
  id: note
  parameters:
    note: Modulation gate
  states: {}
- name: note_0_3_0
  id: note
  parameters:
    note: Tx gate
  states: {}
- name: note_1
  id: note
  parameters:
    note: Manchester Tx timing
  states: {state: disabled}
- name: note_2
  id: note
  parameters:
    note: '"''406.025 MHz''"'
  states: {}
- name: note_3
  id: note
  parameters:
    note: Tx constellation check
  states: {state: disabled}
- name: note_3_0
  id: note
  parameters:
    note: Control signals check
  states: {state: disabled}
- name: note_3_0_0
  id: note
  parameters:
    note: Phase modulator
  states: {}
- name: note_3_0_0_0
  id: note
  parameters:
    note: original value 10
  states: {}
- name: note_4_0
  id: note
  parameters:
    note: fails on plain carrier
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 436e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 4096*6
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_KAISER
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_rxi
    fc: '0'
    fftsize: '8192'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_KAISER
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_rx
    fc: '0'
    fftsize: '8192'
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_KAISER
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: bits_per_second*symbols_per_bit*samples_per_symbol
    fc: '0'
    fftsize: '8192'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_KAISER
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 5*5*bits_per_second*symbols_per_bit*samples_per_symbol
    fc: '0'
    fftsize: '8192'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_KAISER
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    label3: ''
    nconnections: '3'
    size: '4096'
    srate: bits_per_second*symbols_per_bit*samples_per_symbol
    tr_chan: '1'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: 4096*6*2*10
    srate: samp_rate
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 3,0
    label1: Soft Bits
    name: '"Clock Recovered Signal"'
    size: '512'
    srate: samp_rate_rx/samples_per_symbol
    tr_delay: '0.160'
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: float
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/5)
    fbw: '0.45'
    interp: int(bits_per_second*symbols_per_bit*samples_per_symbol)
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_sample_and_hold_xx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_sample_and_hold_xx_0_0, '0']
- [blocks_delay_0, '0', blocks_xor_xx_0, '1']
- [blocks_file_source_0, '0', digital_map_bb_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_1, '1']
- [blocks_float_to_complex_1, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_multiply_xx_0, '0', analog_phase_modulator_fc_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_1, '0', interp_fir_filter_xxx_1, '0']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_repeat_0, '0', blocks_delay_0, '0']
- [blocks_repeat_0, '0', blocks_xor_xx_0, '0']
- [blocks_repeat_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_repeat_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_rotator_cc_0, '0', osmosdr_sink_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_sample_and_hold_xx_0, '0', blocks_float_to_complex_1, '0']
- [blocks_sample_and_hold_xx_0_0, '0', blocks_float_to_complex_1, '1']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '1']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_threshold_ff_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_xor_xx_0, '0', blocks_sample_and_hold_xx_0, '1']
- [blocks_xor_xx_0, '0', blocks_sample_and_hold_xx_0_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [digital_map_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [interp_fir_filter_xxx_1, '0', interp_fir_filter_xxx_1_0, '0']
- [interp_fir_filter_xxx_1_0, '0', interp_fir_filter_xxx_1_0_0, '0']
- [interp_fir_filter_xxx_1_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [interp_fir_filter_xxx_1_0, '0', rational_resampler_xxx_0_0, '0']
- [interp_fir_filter_xxx_1_0_0, '0', blocks_rotator_cc_0, '0']
- [interp_fir_filter_xxx_1_0_0, '0', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_1_0_0, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
